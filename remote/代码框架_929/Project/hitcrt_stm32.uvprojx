# Keil uVision project hitcrt_stm32.uvprojx, settings and files
target Group 3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: group3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\File\Init;..\File\User;..\STM32F4xx_Lib\CORE;..\STM32F4xx_Lib\FWLIB\inc;..\STM32F4xx_Lib\FWLIB\src;..\STM32F4xx_Lib\CORE;..\Documents
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../File/User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../STM32F4xx_Lib/CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../STM32F4xx_Lib/FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group INIT
    ../File/INIT/: all_init.c can.c delay.c led.c pid.c tim.c usart.c
    ../File/Init/: remoter.c dma.c
  group Documents
    ../Documents/: Readme.txt
